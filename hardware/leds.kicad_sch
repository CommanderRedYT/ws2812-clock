File: hardware/leds.kicad_sch (KiCad schematic)
At the start: 467 parts, among them Q3 BSS138

Commit message: Backup from Macbook
Parts:
- renumbered R12 to R17, R12 to R18
